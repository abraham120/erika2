
base 0x0

group e:0xc3f90693++7 "Leds"
textline ""
hexfld.byte 0 " led 0 "
hexfld.byte 1 " led 1 "
hexfld.byte 2 " led 2 "
hexfld.byte 3 " led 3 "
textline ""
hexfld.byte 4 " led 4 "
hexfld.byte 5 " led 5 "
hexfld.byte 6 " led 6 "
hexfld.byte 7 " led 7 "

textline " "
textline " "
button " press " "do press"


